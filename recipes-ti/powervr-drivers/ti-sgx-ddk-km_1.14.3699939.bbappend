SUMMARY = "Add beaglebone to the compatible machines"
COMPATIBLE_MACHINE = "ti33x|ti43x|omap-a15|beaglebone"


