SRC_URI = "\
    file://0001-rc.pvr-add-proper-error-return-code.patch \
    file://0002-rc.pvr-don-t-load-the-bc_example-module.patch \
"
